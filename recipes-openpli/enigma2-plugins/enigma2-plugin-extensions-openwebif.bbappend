    boxtypes += [
	('spark', 'spark.jpg', 'spark.png', 'spark.html'),
        ('spark7162', 'spark7162.jpg', 'spark.png', 'spark.html'),
    ]
