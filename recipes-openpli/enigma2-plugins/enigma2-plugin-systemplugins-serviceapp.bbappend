CXXFLAGS_append += " -std=c++11"
CXXFLAGS_append_sh4 += " -fPIC -fno-strict-aliasing "

