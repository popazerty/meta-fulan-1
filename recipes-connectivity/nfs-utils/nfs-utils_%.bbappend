CFLAGS_remove_sh4 = "-Wno-error=format-overflow"
